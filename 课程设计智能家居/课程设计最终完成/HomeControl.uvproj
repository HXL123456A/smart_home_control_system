# Keil uVision project HomeControl.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: HomeControl +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware\Key;.\System;.\Hardware\InfraRed;.\Hardware\Secret;.\Hardware\LCD1602;.\Hardware\DS18B20;.\Hardware\DS1302;.\Hardware\IIC;.\Hardware\PCF8591;.\Hardware\ULN2003
  group User
    ./: main.c
  group Hardware
    ./Hardware/Key/: Key.c
    ./Hardware/InfraRed/: InfraRed.c
    ./Hardware/LCD1602/: LCD1602.c
    ./Hardware/Secret/: Secret.c
    ./Hardware/DS18B20/: DS18B20.c
    ./Hardware/DS1302/: DS1302.c
    ./Hardware/IIC/: IIC.c
    ./Hardware/PCF8591/: PCF8591.c
    ./Hardware/ULN2003/: ULN2003.c
  group System
    ./System/: Sys.c Delay.c
