# Keil uVision project HomeControl.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: HomeControl +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware\Key;.\System;.\Hardware\InfraRed;.\Hardware\Secret;.\Hardware\LCD1602
  group User
    ./: main.c
  group Hardware
    ./Hardware/Key/: Key.c
    ./Hardware/InfraRed/: InfraRed.c
    ./Hardware/LCD1602/: LCD1602.c
    ./Hardware/Secret/: Secret.c
  group System
    ./System/: Sys.c Delay.c
